# Keil uVision project Solar.uvproj, settings and files
target Solar (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Solar1_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: OVERLAY (main ~ (Comm_Update,Dispatch_Update), hSCH_Dispatch_Tasks 
    ! (Comm_Update,Dispatch_Update))
  group Main
    ../Main/: Main.c 0_02_11h.C hSch51.c
  group Public
    ../Public/: Public.h
  group Comm
    ../Comm/: serialS1.c serialS2.c CommCmdAll.c CommCmdS1.c CommCmdS2.c
  group Input
    ../Input/: Input.c
  group Output
    ../Output/: Output.c beep.c led.c
  group Memory
    ../Memory/: FlashRom.c memory.c
  group Decision
    ../Decision/: Decision.c
  group Error
    ../Error/: Error.c
